# Repository adafruit/Adafruit-CAP1188-PCB

File README.md:

## Adafruit CAP1188 I2C/SPI capacitive touch breakout PCB
<a href="http://www.adafruit.com/products/1602"><br/>
Click here to purchase one from the Adafruit shop</a>

Add lots of touch sensors to your next microcontroller project with this easy-to-use 8-channel capacitive touch sensor breakout board, starring the CAP1188. This chip can handle up to 8 individual touch pads, and has a very nice feature that makes it stand out for us: it will light up the 8 onboard LEDs when the matching touch sensor fires to help you debug your sensor setup.

The CAP1188 has support for both I2C and SPI, so it easy to use with any microcontroller. If you are using I2C, you can select one of 5 addresses, for a total of 40 capacitive touch pads on one I2C 2-wire bus. Using this chip is a lot easier than doing the capacitive sensing with analog inputs: it handles all the filtering for you and can be configured for more/less sensitivity.

PCB files for Adafruit CAP1188. The format is EagleCAD schematic and board layout
- https://www.adafruit.com/product/1602

### License

Adafruit invests time and resources providing this open source design, please support Adafruit and open-source hardware by purchasing products from [Adafruit](https://www.adafruit.com)!

All text above must be included in any redistribution

Designed by Limor Fried/Ladyada for Adafruit Industries.
Creative Commons Attribution/Share-Alike, all text above must be included in any redistribution. 
See license.txt for additional information.

## EAGLE design Adafruit CAP1188.brd

Parts:
C2, C3: 10uF; 0805-NO
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP3, JP4: HEADER-1X13; 1X13_ROUND_70
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8: LED0805; CHIPLED_0805
R1, R2: 470; RESPACK_4X0603
R9, R10, R11, R12: 10K; 0805-NO
R13: 150K; _0805MP
U1: CAP1188; QFN24_4MM_SMSC
U2: MIC5225-3; SOT23-5
U$7, U$8, U$9, U$10: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED

Connections:
3.3V: C3.1, JP3.4, R1.5 (2), R1.6 (2), R1.7 (2), R1.8 (2), R2.5 (2), R2.6 (2), R2.7 (2), R2.8 (2), R9.2, R10.2, R11.2, U1.23 (VDD), U2.5 (OUT)
ADDR: JP3.13, R13.2, U1.14 (ADDR_COMM)
CS: JP3.2, U1.1 (SPI_CS)
CS1: JP3.5, U1.22 (CS1)
CS2: JP3.6, U1.21 (CS2)
CS3: JP3.7, U1.20 (CS3)
CS4: JP3.8, U1.19 (CS4)
CS5: JP3.9, U1.18 (CS5)
CS6: JP3.10, U1.17 (CS6)
CS7: JP3.11, U1.16 (CS7)
CS8: JP3.12, U1.15 (CS8)
GND: C2.2, C3.2, JP4.4, R12.1, R13.1, U1.THERM (THERMAL/GND), U2.2 (GND)
IRQ: JP4.13, R11.1, U1.13 (ALERT#/BC_IRQ#)
LED1: JP4.5, LED1.C, U1.5 (LED1)
LED2: JP4.6, LED2.C, U1.6 (LED2)
LED3: JP4.7, LED3.C, U1.7 (LED3)
LED4: JP4.8, LED4.C, U1.8 (LED4)
LED5: JP4.9, LED5.C, U1.9 (LED5)
LED6: JP4.10, LED6.C, U1.10 (LED6)
LED7: JP4.11, LED7.C, U1.11 (LED7)
LED8: JP4.12, LED8.C, U1.12 (LED8)
unnamed: LED1.A, R1.1
unnamed: LED2.A, R1.2 (1)
unnamed: LED3.A, R1.3 (1)
unnamed: LED4.A, R1.4 (1)
unnamed: LED5.A, R2.1
unnamed: LED6.A, R2.2 (1)
unnamed: LED7.A, R2.3 (1)
unnamed: LED8.A, R2.4 (1)
RESET: JP3.3, R12.2, U1.24 (RESET)
SCK: JP4.2, R10.1, U1.4 (SMCLK/BC_CLK/SPI_CLK)
SDA/MISO: JP4.1, R9.1, U1.3 (SMDATA/BC_DATA/SPI_MISO)
VIN: C2.1, JP4.3, U2.1 (IN), U2.3 (EN)
WAKE/MOSI: JP3.1, U1.2 (WAKE/SPI_MOSI)

Notes on the sheet:
R13 Value (ADDR_COMM)
SPI Four Wire
56K
SPI 3-Wire
68K
BC-Link
82K
I2C
0101100x
0101011x
0101010x
0101001x
0101000x
100K
120K
150K
VDD

Board: 2 copper layers, 17.8 x 41.9 mm, 29 parts (1 on the bottom side), 34 nets.

Other parts of the board:
U$13: ADAFRUIT_3.5MM
U$14: ADAFRUIT_9MM

## Commit log

2014-06-26 gogogo

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
